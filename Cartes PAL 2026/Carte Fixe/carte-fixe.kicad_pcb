# Repository evolutek/carte-actionneurs (continued)

## KiCad design Carte ADC/carte-adc.kicad_pcb

Parts:
C1, C3: 1uF; C_0603_1608Metric
C2, C4, C5, C6, C7: 100nF; C_0603_1608Metric
C8, C9, C10, C11: C; C_0603_1608Metric; not fitted
D1: RED; LED_0805_2012Metric
D2, D3, D4, D5: 3V; D_SOD-523
H1, H2, H3, H4: M3; MountingHole_3.2mm_M3_Pad_Via
J1, J2: Bus Evo; 690367281076
J3, J4, J5, J6: Input; B03B-PASK
JP1, JP2, JP3, JP4: SolderJumper_3_Open; SolderJumper-3_P1.3mm_Open_RoundedPad1.0x1.5mm
LB1: LOGO; logo-evo-min
LB2: LOGO; Logo Aisler Min
R1, R2: 4.7k; R_0603_1608Metric; not fitted
R3: 10k; R_0603_1608Metric
R4: 510; R_0603_1608Metric
R5, R6, R7, R8: R2; R_0603_1608Metric; not fitted
R9, R10, R11, R12: R1; R_0603_1608Metric; not fitted
SW1: SW_DIP_x01; SW_DIP_SPSTx01_Slide_6.7x4.1mm_W7.62mm_P2.54mm_LowProfile
U1: NCP718xSN330; SOT-23-5
U2: ADS1115IDGS; TSSOP-10_3x3mm_P0.5mm

Connections:
+3.3V: C2.1, C3.1, D1.2 (A), R1.1, R2.1, SW1.2, U1.5 (OUT), U2.8 (VDD)
+5VL: C1.1, J1.1, J2.1, JP1.3 (B), JP2.3 (B), JP3.3 (B), JP4.3 (B), U1.1 (IN), U1.3 (EN)
+12L: J1.2, J2.2, JP1.1 (A), JP2.1 (A), JP3.1 (A), JP4.1 (A)
/AIN0: C8.1, D2.1 (K), R5.1, R9.1, U2.4 (AIN0)
/AIN1: C9.1, D3.1 (K), R6.1, R10.1, U2.5 (AIN1)
/AIN2: C10.1, D4.1 (K), R7.1, R11.1, U2.6 (AIN2)
/AIN3: C11.1, D5.1 (K), R8.1, R12.1, U2.7 (AIN3)
/AU: J1.7, J2.7
/CANH: J1.9, J2.9
/CANL: J1.10, J2.10
/RST: J1.8, J2.8
/SCL: J1.6, J2.6, R2.2, U2.10 (SCL)
/SDA: J1.5, J2.5, R1.2, U2.9 (SDA)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, D2.2 (A), D3.2 (A), D4.2 (A), D5.2 (A), H1.1, H2.1, H3.1, H4.1, J1.3, J1.4, J2.3, J2.4, J3.3, J4.3, J5.3, J6.3, R3.2, R4.2, R5.2, R6.2, R7.2, R8.2, U1.2 (GND), U2.3 (GND)
unnamed: D1.1 (K), R4.1
unnamed: C4.1, J3.1, JP1.2 (C)
unnamed: J3.2, R9.2
unnamed: C5.1, J4.1, JP2.2 (C)
unnamed: J4.2, R10.2
unnamed: C6.1, J5.1, JP3.2 (C)
unnamed: J5.2, R11.2
unnamed: C7.1, J6.1, JP4.2 (C)
unnamed: J6.2, R12.2
unnamed: R3.1, SW1.1, U2.1 (ADDR)

Notes on the sheet:
Sensors Configurations
Bus Actuators
ADC
Mounting Holes
Power Led
3.3V Regulation
Logos
Inputs
I2C addr : 0x48-0x49
Analog (20mA)
Alimentation
12V
Analog (5V)
Distance sensor indus (WTT12L)
33K
10K
Digital (5V)
Digital (12V)
TOR indus(GTB2S/GTB6)
5.1K
Capteur
150
Output Type
Distance sensor (Sharp IR)

Board: 2 copper layers, 35.0 x 35.0 mm, 55 parts (35 on the bottom side), 24 nets.

Other parts of the board:
kibuzzard-682DD3F9: G***; kibuzzard-682DD3F9
kibuzzard-682DD3FF: G***; kibuzzard-682DD3FF
kibuzzard-682DD415: G***; kibuzzard-682DD415
kibuzzard-682DD421: G***; kibuzzard-682DD421
kibuzzard-682DD448, kibuzzard-682DD448#2: G***; kibuzzard-682DD448
kibuzzard-682DD483: G***; kibuzzard-682DD483
kibuzzard-682DD754: G***; kibuzzard-682DD754

## KiCad design Carte Stepper V1/carte-stepper.kicad_pcb

Parts:
C1, C3: 1uF; C_0603_1608Metric
C2, C4, C6, C8, C10, C11, C12: 100nF; C_0603_1608Metric
C5: 10uF; C_0603_1608Metric
C7: 10nF; C_0603_1608Metric
C9: 330uF; CP_Radial_D10.0mm_P5.00mm
D1: D; D_SOD-523
D2, D3: RED; LED_0805_2012Metric
D4: GREEN; LED_0805_2012Metric
D5: YELLOW; LED_0805_2012Metric
D6, D7, D8: 3V; D_SOD-523
H1, H2, H3, H4: M3; MountingHole_3.2mm_M3_Pad_Via
J1: USB_B_Mini; USB_Mini-B_Wuerth_65100516121_Horizontal
J2: STLINK; 62701420621
J3: Bus Actuators; 690367281076
J4: Bus Actuators; 690367281076; not fitted
J5: Actuators PSU; 649006227222
J6: Actuators PSU; 649006227222; not fitted
J7, J8, J9: Motor; 690367280676
J10, J11, J12: Sensor; B03B-PASK
J13, J14, J15: AX12; 22-03-5035; not fitted
JP1: SolderJumper_2_Open; SolderJumper-2_P1.3mm_Open_RoundedPad1.0x1.5mm
JP2, JP3, JP4: SolderJumper_3_Open; SolderJumper-3_P1.3mm_Open_RoundedPad1.0x1.5mm
LB1: LOGO; logo-evo-min
LB2: LOGO; Logo Aisler Min
LB3: CAN ID Label 2
Q1: Q_NMOS_GSD; SOT-23
R1: 100k; R_0603_1608Metric
R2: 120; R_0603_1608Metric
R3, R10: 10k; R_0603_1608Metric
R4, R6, R7, R9: 510; R_0603_1608Metric
R5: 10k; R_0603_1608Metric; not fitted
R8: 0; R_0603_1608Metric
R11, R12, R13: R2; R_0603_1608Metric; not fitted
R14, R15, R16: R1; R_0603_1608Metric; not fitted
R17, R18: 4.7k; R_0603_1608Metric
SW1: 435431019840
U1: WE-TVS-82400102; SOT-23-6
U2: MCP2551-I-SN; SOIC-8_3.9x4.9mm_P1.27mm
U3: NCP718xSN330; SOT-23-5
U4: STM32G491KEUx; QFN-32-1EP_5x5mm_P0.5mm_EP3.45x3.45mm-Without thermal pad

Connections:
+3.3V: C3.1, C5.1, C6.1, C7.1, C8.1, D3.2 (A), J2.3, R5.1, R17.1, R18.1, U3.5 (OUT), U4.1 (VDD), U4.15 (VDDA), U4.17 (VDD)
+5P: D2.2 (A), J5.3, J6.3
+5VL: C1.1, C4.1, D1.1 (K), J3.1, J4.1, JP2.3 (B), JP3.3 (B), JP4.3 (B), U1.5, U2.3 (VDD), U3.1 (IN), U3.3 (EN)
+12L: J3.2, J4.2, JP2.1 (A), JP3.1 (A), JP4.1 (A)
+12P: J5.2, J6.2, J13.2, J14.2, J15.2
/AU: J3.7, J4.7, U4.13 (PB0)
/AX12: J13.1, J14.1, J15.1
/CANH: J3.9, J4.9, R2.1, U2.7 (CANH)
/CANL: J3.10, J4.10, JP1.2 (B), U2.6 (CANL)
/CAN_RX: U2.4 (RXD), U4.28 (PB5)
/CAN_TX: U2.1 (TXD), U4.29 (PB6)
/MOTOR_DIR_A: J7.6, U4.25 (PA15)
/MOTOR_DIR_B: J8.6, U4.27 (PB4)
/MOTOR_DIR_C: J9.6, U4.10 (PA5)
/MOTOR_EN: D5.2 (A), J7.4, J8.4, J9.4, U4.5 (PA0)
/MOTOR_STP_A: J7.5, U4.20 (PA10)
/MOTOR_STP_B: J8.5, U4.26 (PB3)
/MOTOR_STP_C: J9.5, U4.9 (PA4)
/RST: J3.8, J4.8, Q1.1 (G), R3.1
/SCL: J3.6, J4.6, R18.2, U4.19 (PA9)
/SDA: J3.5, J4.5, R17.2, U4.18 (PA8)
/SENSOR1: D6.1 (K), R11.1, R14.2, U4.6 (PA1)
/SENSOR2: D7.1 (K), R12.1, R15.2, U4.11 (PA6)
/SENSOR3: D8.1 (K), R13.1, R16.2, U4.12 (PA7)
/STATUS: D4.2 (A), U4.30 (PB7)
/SWCLK: J2.6, U4.24 (PA14)
/SWDIO: J2.4, U4.23 (PA13)
/USB_D+: U1.6, U4.22 (PA12)
/USB_D-: U1.4, U4.21 (PA11)
/VCP_RX: J2.13, U4.8 (PA3)
/VCP_TX: J2.14, U4.7 (PA2)
/~RST: C2.1, J2.12, Q1.3 (D), R5.2, SW1.4, U4.4 (PG10)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, D6.2 (A), D7.2 (A), D8.2 (A), H1.1, H2.1, H3.1, H4.1, J1.5 (GND), J1.6 (Shield), J2.5, J2.7, J2.11, J3.3, J3.4, J4.3, J4.4, J5.4, J5.5, J5.6, J6.4, J6.5, J6.6, J7.2, J8.2, J9.2, J10.3, J11.3, J12.3, J13.3, J14.3, J15.3, Q1.2 (S), R1.2, R3.2, R4.2, R6.2, R7.2, R8.1, R9.2, R10.2, R11.2, R12.2, R13.2, SW1.3, SW1.SH, U1.2, U2.2 (VSS), U3.2 (GND), U4.14 (VSSA), U4.16 (VSS), U4.32 (VSS)
unnamed: D2.1 (K), R4.1
unnamed: D3.1 (K), R6.1
unnamed: D4.1 (K), R7.1
unnamed: D5.1 (K), R9.1
unnamed: J1.3 (D+), U1.1
unnamed: J1.2 (D-), U1.3
unnamed: J1.4 (ID), R1.1
unnamed: C10.1, J10.1, JP2.2 (C)
unnamed: J10.2, R14.1
unnamed: C11.1, J11.1, JP3.2 (C)
unnamed: J11.2, R15.1
unnamed: C12.1, J12.1, JP4.2 (C)
unnamed: J12.2, R16.1
unnamed: JP1.1 (A), R2.2
unnamed: R8.2, U2.8 (Rs)
unnamed: R10.1, U4.31 (PB8)
VBUS: D1.2 (A), J1.1 (VBUS)
VPP: C9.1, J5.1, J6.1, J7.1, J8.1, J9.1

Notes on the sheet:
USB Port
Leds
Reset Circuit
Logos
Sensors
I2C Pullups
AX12
3.3V LDO
Bus CAN
STLINK
Mounting holes
Stepper motors
Actuators PSU
Bus Actuators
TODO : MAPPING

Board: 2 copper layers, 70.0 x 50.0 mm, 79 parts (26 on the bottom side), 51 nets.

Other parts of the board:
kibuzzard-6823F4BA: G***; kibuzzard-6823F4BA
kibuzzard-6823F4E3: G***; kibuzzard-6823F4E3
kibuzzard-6823F4F6: G***; kibuzzard-6823F4F6
kibuzzard-6823F54E: G***; kibuzzard-6823F54E
kibuzzard-6823F58E: G***; kibuzzard-6823F58E
kibuzzard-6823F460: G***; kibuzzard-6823F460
kibuzzard-6823F506: G***; kibuzzard-6823F506
kibuzzard-6823F533: G***; kibuzzard-6823F533
kibuzzard-6823F573: G***; kibuzzard-6823F573

## KiCad design Hub Bus Actuators/hub-bus-actuators.kicad_pcb

Parts:
C1: 100nF; C_0603_1608Metric; not fitted
D1, D2: YELLOW; LED_0805_2012Metric; not fitted
D3, D4: RED; LED_0805_2012Metric; not fitted
H1, H2, H3, H4: M3; MountingHole_3.2mm_M3_Pad_Via
J1, J2, J3: PSU Bus Actuators; 649006227222
J4: I2C; B04B-PASK
J5: CAN; B04B-PASK
J6, J7, J8: Bus Actuators; 690367281076
J9: PSU; 66200421022
J10, J11, J12: AX12; 22-03-5035
LB1: LOGO; Logo Aisler Min
LB2: LOGO; logo-evo-min
R1, R2, R4, R6, R7, R8: 510; R_0603_1608Metric; not fitted
R3, R5: 1k; R_0603_1608Metric; not fitted
SW1: SW_DPDT_x2; 452404020202; not fitted
SW2: 435431019840; not fitted

Connections:
+5P: D4.2 (A), J1.3, J2.3, J3.3
+5VL: D3.2 (A), J4.1, J5.1, J6.1, J7.1, J8.1, J9.2, SW1.1 (A), SW2.3
+12L: J6.2, J7.2, J8.2, J9.1
+12P: J1.2, J2.2, J3.2, J10.2, J11.2, J12.2
/AU: J6.7, J7.7, J8.7, R2.2, R3.1
/AX12: J10.1, J11.1, J12.1
/CANH: J5.2, J6.9, J7.9, J8.9
/CANL: J5.3, J6.10, J7.10, J8.10
/RST: C1.1, J6.8, J7.8, J8.8, R4.2, R5.1
/SCL: J4.3, J6.6, J7.6, J8.6
/SDA: J4.2, J6.5, J7.5, J8.5
GND: C1.2, H1.1, H2.1, H3.1, H4.1, J1.4, J1.5, J1.6, J2.4, J2.5, J2.6, J3.4, J3.5, J3.6, J4.4, J5.4, J6.3, J6.4, J7.3, J7.4, J8.3, J8.4, J9.3, J9.4, J10.3, J11.3, J12.3, R1.2, R3.2, R5.2, R6.2, R7.2, R8.2, SW2.SH
unnamed: D1.2 (A), R2.1, SW1.2 (B)
unnamed: D1.1 (K), R1.1
unnamed: D2.2 (A), R4.1, SW2.4
unnamed: D2.1 (K), R6.1
unnamed: D3.1 (K), R7.1
unnamed: D4.1 (K), R8.1
VPP: J1.1, J2.1, J3.1

Notes on the sheet:
Debug Ports
PSU Bus Actuators
Bus Actuators
AX12
Power Leds
Logos
Mounting Holes

Board: 2 copper layers, 70.0 x 40.0 mm, 37 parts (11 on the bottom side), 19 nets.

Other parts of the board:
kibuzzard-68224E62: G***; kibuzzard-68224E62
kibuzzard-68224EAF: G***; kibuzzard-68224EAF
kibuzzard-68224EC2: G***; kibuzzard-68224EC2
kibuzzard-68224FF3: G***; kibuzzard-68224FF3

## KiCad design V3 - Bis/carte-actionneurs.kicad_pcb

Parts:
C1, C5: 10uF; C_0603_1608Metric
C2, C4: 100uF; CP_Elec_6.3x7.7
C3, C6, C7, C8, C9, C12, C13, C14, C15: 100nF; C_0603_1608Metric
C10, C11, C16, C17: 4.7uF; C_0603_1608Metric
D1, D2: RED; LED_0805_2012Metric
D3, D4, D5, D6, D7, D8, D9, D10: 3V; D_SOD-523
H1, H2, H3, H4: M3; MountingHole_3.2mm_M3_Pad_Via
J1: Bus Actuators; 690367281076; not fitted
J2: Logic PSU; 66200421022
J3: Actuators PSU; 649006227222
J4: Actuators PSU; 649006227222; not fitted
J5, J6, J8, J9, J13, J14, J15, J16, J17, J18: Servo; PinHeader_1x03_P2.54mm_Vertical
J7: I2C; S04B-PASK
J10, J11, J12: AX12; 22-03-5035
J19, J20, J25, J26: Pumps; B04B-PASK
J21, J22, J23, J24, J27, J28, J29, J30: Sensor; B03B-PASK
LB1: LOGO; Logo Aisler Micro
LB2: LOGO; logo-evo-micro
R1: 1k; R_0603_1608Metric
R2, R8, R10: 4.7k; R_0603_1608Metric
R3, R4, R5, R6, R7, R9, R11, R22, R23, R24, R25, R30, R31, R32, R33: 10k; R_0603_1608Metric
R12, R13, R14, R15, R16, R17, R18, R19, R20, R21: 220; R_0603_1608Metric
R26, R27, R28, R29, R34, R35, R36, R37: 33k; R_0603_1608Metric
SW1, SW2: SW_DIP_x03; SW_DIP_SPSTx03_Slide_KingTek_DSHP03TS_W7.62mm_P1.27mm
U1: NCP718xSN330; SOT-23-5
U2: PCA9685PW; TSSOP-28_4.4x9.7mm_P0.65mm
U3: MCP23017_SS; SSOP-28_5.3x10.2mm_P0.65mm

Connections:
+3.3V: C3.1, R8.1, R10.1, SW2.1, SW2.2, SW2.3, U1.5 (OUT), U3.9 (VDD), U3.18 (~RESET)
+5P: C4.1, J3.3, J4.3, J5.2, J6.2, J8.2, J9.2, J13.2, J14.2, J15.2, J16.2, J17.2, J18.2
+5VL: C1.1, C5.2, D1.2 (A), J1.1, J2.2, J7.1, SW1.1, SW1.2, SW1.3, U1.1 (IN), U1.3 (EN), U2.28 (VDD)
+12L: C6.2, C7.2, C8.2, C9.2, C12.2, C13.2, C14.2, C15.2, J1.2, J2.1, J21.1, J22.1, J23.1, J24.1, J27.1, J28.1, J29.1, J30.1
+12P: C2.1, C10.1, C11.1, C16.1, C17.1, D2.2 (A), J3.2, J4.2, J10.2, J11.2, J12.2, J19.1, J20.1, J25.1, J26.1
/A0: D3.1 (K), R22.2, R26.1, U3.21 (GPA0)
/A1: D4.1 (K), R23.2, R27.1, U3.22 (GPA1)
/A2: D5.1 (K), R24.2, R28.1, U3.23 (GPA2)
/A3: D6.1 (K), R25.2, R29.1, U3.24 (GPA3)
/A4: D7.1 (K), R30.2, R34.1, U3.25 (GPA4)
/A5: D8.1 (K), R31.2, R35.1, U3.26 (GPA5)
/A6: D9.1 (K), R32.2, R36.1, U3.27 (GPA6)
/A7: D10.1 (K), R33.2, R37.1, U3.28 (GPA7)
/AX12: J10.1, J11.1, J12.1
/B0: J19.2, U3.1 (GPB0)
/B1: J20.2, U3.2 (GPB1)
/B2: J19.3, U3.3 (GPB2)
/B3: J20.3, U3.4 (GPB3)
/B4: J25.2, U3.5 (GPB4)
/B5: J26.2, U3.6 (GPB5)
/B6: J25.3, U3.7 (GPB6)
/B7: J26.3, U3.8 (GPB7)
/PWM0: J5.1, R12.2
/PWM1: J6.1, R13.2
/PWM2: J8.1, R14.2
/PWM3: J9.1, R15.2
/PWM4: J13.1, R16.2
/PWM5: J14.1, R17.2
/PWM6: J15.1, R18.2
/PWM7: J16.1, R19.2
/PWM8: J17.1, R20.2
/PWM9: J18.1, R21.2
/SCL: J1.6, J7.3, R8.2, U2.26 (SCL), U3.12 (SCK)
/SDA: J1.5, J7.2, R10.2, U2.27 (SDA), U3.13 (SDA)
GND: C1.2, C2.2, C3.2, C4.2, C5.1, C6.1, C7.1, C8.1, C9.1, C10.2, C11.2, C12.1, C13.1, C14.1, C15.1, C16.2, C17.2, D3.2 (A), D4.2 (A), D5.2 (A), D6.2 (A), D7.2 (A), D8.2 (A), D9.2 (A), D10.2 (A), H1.1, H2.1, H3.1, H4.1, J1.3, J1.4, J2.3, J2.4, J3.4, J3.5, J3.6, J4.4, J4.5, J4.6, J5.3, J6.3, J7.4, J8.3, J9.3, J10.3, J11.3, J12.3, J13.3, J14.3, J15.3, J16.3, J17.3, J18.3, J19.4, J20.4, J21.3, J22.3, J23.3, J24.3, J25.4, J26.4, J27.3, J28.3, J29.3, J30.3, R1.2, R2.2, R3.2, R4.2, R5.2, R6.1, R7.2, R9.2, R11.2, R22.1, R23.1, R24.1, R25.1, R30.1, R31.1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
unnamed: D1.1 (K), R1.1
unnamed: D2.1 (K), R2.1
unnamed: J21.2, R26.2
unnamed: J22.2, R27.2
unnamed: J23.2, R28.2
unnamed: J24.2, R29.2
unnamed: J27.2, R34.2
unnamed: J28.2, R35.2
unnamed: J29.2, R36.2
unnamed: J30.2, R37.2
unnamed: R3.1, SW1.6, U2.1 (A0)
unnamed: R4.1, SW1.5, U2.2 (A1)
unnamed: R5.1, SW1.4, U2.3 (A2)
unnamed: R12.1, U2.6 (LED0)
unnamed: R13.1, U2.7 (LED1)
unnamed: R14.1, U2.8 (LED2)
unnamed: R15.1, U2.9 (LED3)
unnamed: R16.1, U2.10 (LED4)
unnamed: R17.1, U2.11 (LED5)
unnamed: R18.1, U2.12 (LED6)
unnamed: R19.1, U2.13 (LED7)
unnamed: R20.1, U2.15 (LED8)
unnamed: R21.1, U2.16 (LED9)
unnamed: R6.2, U2.23 (~OE)
unnamed: R7.1, SW2.6, U3.15 (A0)
unnamed: R9.1, SW2.5, U3.16 (A1)
unnamed: R11.1, SW2.4, U3.17 (A2)
VPP: J3.1, J4.1

Notes on the sheet:
Decoupling
LEDs controller
Pumps
3.3V Regulation
AX12
Gpio Expandeur
Bus Actuators
PSU
Sensors
I2C
Leds
Servos
Logos
Mounting Holes
MCP can be on the addresses 0x20-0x27 (configured on SW2)
PCA can be on the addresses 0x40-0x47 (configured via SW1)
