# Repository evolutek/carte-actionneurs (continued)

## KiCad design V3 - Bis/carte-actionneurs.kicad_pcb (continued)

Board: 2 copper layers, 60.0 x 60.0 mm, 142 parts (63 on the bottom side), 63 nets.

Other parts of the board:
kibuzzard-67DB1DCF: G***; kibuzzard-67DB1DCF
kibuzzard-67DB1EBA: G***; kibuzzard-67DB1EBA
kibuzzard-67DB1F5A: G***; kibuzzard-67DB1F5A
kibuzzard-67DB1F7E: G***; kibuzzard-67DB1F7E
kibuzzard-67DB20D4: G***; kibuzzard-67DB20D4
kibuzzard-67DB21C8: G***; kibuzzard-67DB21C8
kibuzzard-67DB21E7: G***; kibuzzard-67DB21E7
kibuzzard-67DB24C4: G***; kibuzzard-67DB24C4
kibuzzard-67DB24DA: G***; kibuzzard-67DB24DA
kibuzzard-67DB24FC: G***; kibuzzard-67DB24FC
kibuzzard-67DB25A1: G***; kibuzzard-67DB25A1
kibuzzard-67DB25A9: G***; kibuzzard-67DB25A9
kibuzzard-67DB249C, kibuzzard-67DB249C#2: G***; kibuzzard-67DB249C
kibuzzard-67DB250F: G***; kibuzzard-67DB250F
kibuzzard-67DB254D: G***; kibuzzard-67DB254D
kibuzzard-67DB255B: G***; kibuzzard-67DB255B
kibuzzard-67DB255E: G***; kibuzzard-67DB255E
kibuzzard-67DB258B: G***; kibuzzard-67DB258B
kibuzzard-67DB2328: G***; kibuzzard-67DB2328
kibuzzard-67DB2592: G***; kibuzzard-67DB2592
kibuzzard-67DC45A0: G***; kibuzzard-67DC45A0
kibuzzard-67DC45A4: G***; kibuzzard-67DC45A4
kibuzzard-67DC45A8: G***; kibuzzard-67DC45A8
kibuzzard-67DC45AC: G***; kibuzzard-67DC45AC
kibuzzard-67DC45B0: G***; kibuzzard-67DC45B0
kibuzzard-67DC45B3: G***; kibuzzard-67DC45B3
kibuzzard-67DC45B7: G***; kibuzzard-67DC45B7
kibuzzard-67DC45BB: G***; kibuzzard-67DC45BB
kibuzzard-67DC45E2, kibuzzard-67DC45E2#2: G***; kibuzzard-67DC45E2
kibuzzard-67DC459C: G***; kibuzzard-67DC459C
kibuzzard-67DC4572: G***; kibuzzard-67DC4572
kibuzzard-660644DA, kibuzzard-660644DA#2: G***; kibuzzard-660644DA
kibuzzard-6606460E: G***; kibuzzard-6606460E
kibuzzard-66064268: G***; kibuzzard-66064268

## Code that names these connections

File Carte Stepper V1/firmware/carte-stepper.ioc (part):

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Mcu.Name=STM32G491K(C-E)Ux
Mcu.Package=UFQFPN32
Mcu.UserName=STM32G491KEUx
PA0.GPIOParameters=GPIO_Label
PA0.GPIO_Label=MOTOR_EN
PA0.Signal=GPIO_Output
PA1.GPIOParameters=GPIO_Label
PA1.GPIO_Label=SENSOR1
PA1.Signal=GPXTI1
PA10.GPIOParameters=GPIO_Label
PA10.GPIO_Label=MOTOR_STP_A
PA10.Signal=S_TIM1_CH3
PA11.Mode=Device
PA11.Signal=USB_DM
PA12.Mode=Device
PA12.Signal=USB_DP
PA13.Mode=Serial_Wire
PA13.Signal=SYS_JTMS-SWDIO
PA14.Mode=Serial_Wire
PA14.Signal=SYS_JTCK-SWCLK
PA15.GPIOParameters=GPIO_Label
PA15.GPIO_Label=MOTOR_DIR_A
PA15.Signal=GPIO_Output
PA2.GPIOParameters=GPIO_Label
PA2.GPIO_Label=VCP_TX
PA2.Mode=Asynchronous
PA2.Signal=USART2_TX
PA3.GPIOParameters=GPIO_Label
PA3.GPIO_Label=VCP_RX
PA3.Mode=Asynchronous
PA3.Signal=USART2_RX
PA4.GPIOParameters=GPIO_Label
PA4.GPIO_Label=MOTOR_STP_C
PA4.Signal=S_TIM3_CH2
PA5.GPIOParameters=GPIO_Label
PA5.GPIO_Label=MOTOR_DIR_C
PA5.Signal=GPIO_Output
PA6.GPIOParameters=GPIO_Label
PA6.GPIO_Label=SENSOR2
PA6.Signal=GPXTI6
PA7.GPIOParameters=GPIO_Label
PA7.GPIO_Label=SENSOR3
PA7.Signal=GPXTI7
PA8.Mode=I2C
PA8.Signal=I2C2_SDA
PA9.Mode=I2C
PA9.Signal=I2C2_SCL
PB0.GPIOParameters=GPIO_Label
PB0.GPIO_Label=AU
PB0.Signal=GPXTI0
PB3.GPIOParameters=GPIO_Label
PB3.GPIO_Label=MOTOR_STP_B
PB3.Signal=S_TIM2_CH2
PB4.GPIOParameters=GPIO_Label
PB4.GPIO_Label=MOTOR_DIR_B
PB4.Signal=GPIO_Output
PB5.GPIOParameters=GPIO_Label
PB5.GPIO_Label=CAN_RX
PB5.Mode=FDCAN_Activate
PB5.Signal=FDCAN2_RX
PB6.GPIOParameters=GPIO_Label
PB6.GPIO_Label=CAN_TX
PB6.Mode=FDCAN_Activate
PB6.Signal=FDCAN2_TX
PB7.GPIOParameters=GPIO_Label
PB7.GPIO_Label=STATUS
PB7.Signal=GPIO_Output
RCC.HSE_VALUE=8000000
RCC.SYSCLKFreq_VALUE=168000000
RCC.SYSCLKSource=RCC_SYSCLKSOURCE_PLLCLK
board=custom

File Cartes PAL 2026/Carte Fixe/carte-fixe.ioc (part):

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Mcu.Name=STM32G491K(C-E)Ux
Mcu.Package=UFQFPN32
Mcu.UserName=STM32G491KEUx
PA0.GPIOParameters=GPIO_Label
PA0.GPIO_Label=MOTOR_EN
PA0.Signal=GPIO_Output
PA1.GPIOParameters=GPIO_Label
PA1.GPIO_Label=SENSOR1
PA1.Signal=GPXTI1
PA10.GPIOParameters=GPIO_Label
PA10.GPIO_Label=MOTOR_STP_1
PA10.Signal=S_TIM1_CH3
PA11.GPIOParameters=GPIO_Label
PA11.GPIO_Label=MOTOR_DIR_1
PA11.Signal=GPIO_Output
PA13.Mode=Serial_Wire
PA13.Signal=SYS_JTMS-SWDIO
PA14.Mode=Serial_Wire
PA14.Signal=SYS_JTCK-SWCLK
PA15.GPIOParameters=GPIO_Label
PA15.GPIO_Label=BUS_SCL
PA15.Mode=I2C
PA15.Signal=I2C1_SCL
PA2.GPIOParameters=GPIO_Label
PA2.GPIO_Label=VCP_TX
PA2.Mode=Asynchronous
PA2.Signal=USART2_TX
PA3.GPIOParameters=GPIO_Label
PA3.GPIO_Label=VCP_RX
PA3.Mode=Asynchronous
PA3.Signal=USART2_RX
PA4.GPIOParameters=GPIO_Label
PA4.GPIO_Label=MOTOR_STP_2
PA4.Signal=S_TIM3_CH2
PA5.GPIOParameters=GPIO_Label
PA5.GPIO_Label=MOTOR_DIR_2
PA5.Signal=GPIO_Output
PA7.GPIOParameters=GPIO_Label
PA7.GPIO_Label=SENSOR2
PA7.Signal=GPXTI7
PA8.GPIOParameters=GPIO_Label
PA8.GPIO_Label=STM32_SDA
PA8.Mode=I2C
PA8.Signal=I2C2_SDA
PA9.GPIOParameters=GPIO_Label
PA9.GPIO_Label=STM32_SCL
PA9.Mode=I2C
PA9.Signal=I2C2_SCL
PB0.GPIOParameters=GPIO_Label
PB0.GPIO_Label=STATUS
PB0.Signal=GPIO_Output
PB5.GPIOParameters=GPIO_Label
PB5.GPIO_Label=CAN_RX
PB5.Mode=FDCAN_Activate
PB5.Signal=FDCAN2_RX
PB6.GPIOParameters=GPIO_Label
PB6.GPIO_Label=CAN_TX
PB6.Mode=FDCAN_Activate
PB6.Signal=FDCAN2_TX
PB7.GPIOParameters=GPIO_Label
PB7.GPIO_Label=BUS_SDA
PB7.Mode=I2C
PB7.Signal=I2C1_SDA
RCC.HSE_VALUE=8000000
RCC.SYSCLKFreq_VALUE=168000000
RCC.SYSCLKSource=RCC_SYSCLKSOURCE_PLLCLK
board=custom

## Commit log

2021-01-08 Add actuators part of the new motherboard
2021-01-11 Schematic almost done
2021-01-11 Schematic done
2021-01-11 Schematic fixes
2021-01-13 Started PCB
2021-01-14 PCB almost done
2021-01-15 PCB done
2021-01-20 2nd routing done
2021-01-20 PCB improvements
2021-01-20 Release V1.0
2021-01-31 bom, step, pdf
2021-02-14 V1.1 Removed Nucleo 5V, add LEDS mosfet
2021-02-14 Fixed unconnected GND + IC orientation helpers
2021-02-20 pdfs, step, gerber, bom
2021-02-22 Fabrication output for V1.1
2021-02-23 LEDS were on wrong GPIO bank
2021-02-24 Graphics fixes
2021-03-07 Added recal sensors note
2021-03-14 Updated schematics.pdf
2021-04-18 Replaced the ADS1114 by an ADS1115
2021-04-21 Fixes
2021-05-02 Led strip mosfet gate pulldown
2021-05-09 fabrication output
2021-12-27 Add a test board for a h bridge component
2022-05-01 Add Carte Rallonge Actionneurs 2022 V1
2022-05-01 Fix gueule
2023-03-06 Wip Carte Acts V2
2023-03-07 Wip V2.0
2023-03-13 Add TCA9548A on the schematics
2023-03-13 Wip pcb
2023-03-15 Release V2.0
2023-04-03 Fix servos pinout and minor fixes
2023-04-03 Fix ESCs mapping
2024-03-29 Add V3.0
2024-03-29 Fix I2C mistake
2024-03-29 Fix schematics
2025-03-19 WIP carte actionneurs V3-Bis
2025-03-19 WIP V3-Bis
2025-03-19 WIP V3 Bis
2025-03-20 Carte Actionneurs V3.0 Bis
2025-03-24 generated 3D files
2025-04-28 WIP carte stepper v1
2025-04-30 WIP Carte stepper V1.0
2025-05-01 WIP Carte Stepper
2025-05-12 Release Hub Bus Actuators V1.0
2025-05-14 Release Carte Stepper V1.0
2025-05-20 basic functionnality test
    all 3 motors seem OK
2025-05-21 Release Carte ADC V1.0
2025-05-24 Use code from Steppers-V2-IRQ from carte-asserv-holo repo
2025-05-24 working homing with interrupt and everything working (normally)
2025-05-24 update: Use slower decel when going down
2025-06-11 Swap I2C
2026-03-15 initial
2026-03-15 Remove backups
2026-03-15 ignore backup folders
2026-03-30 Regenerate Doigts Output
2026-03-30 Regenerate output
2026-03-30 Rename archive
2026-03-30 Carte Mobile V1.0
2026-05-03 WIP Carte Fixe
2026-05-05 Carte Fixe V1.0
