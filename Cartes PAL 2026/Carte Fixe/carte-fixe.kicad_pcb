# Repository evolutek/carte-actionneurs

## KiCad design Cartes PAL 2026/Carte Fixe/carte-fixe.kicad_pcb

Parts:
C1, C4, C5: 100uF; CP_Elec_6.3x7.7
C2, C7, C13: 10uF; C_0603_1608Metric
C3, C6, C8, C10, C11, C15, C16: 100nF; C_0603_1608Metric
C9: 10nF; C_0603_1608Metric
C12, C14, C17, C18: 4.7uF; C_0603_1608Metric
D1, D2: RED; LED_0805_2012Metric
D3: GREEN; LED_0805_2012Metric
D4: YELLOW; LED_0805_2012Metric
H1, H2, H3, H4: M3; MountingHole_3.2mm_M3_Pad_Via
J1, J2, J5, J6, J8, J9, J10, J11, J12: AX12; 22-03-5035
J3: Sous-bus CAN/I2C; 690367280676
J4: STLINK; 62701420621
J7: Actuators PSU; 649006227222
J13, J17: ESC; PinHeader_1x03_P2.54mm_Vertical
J14, J15: Motor; 690367280676
J16, J19, J23, J27: Pump; B04B-PASK
J18, J20: ESC Power; 649002227222
J21, J22: Sensor; B03B-PASK
J24, J25: SBE I2C; 690367280676
J26, J28, J29, J30: Servo; PinHeader_1x03_P2.54mm_Vertical
JP1, JP2, JP3: Jumper_3_Open; SolderJumper-3_P1.3mm_Open_RoundedPad1.0x1.5mm
JP4, JP5: SolderJumper_3_Open; SolderJumper-3_P1.3mm_Open_RoundedPad1.0x1.5mm
LB1: CAN ID Label 2
LB2: LOGO; logo-evo-micro
LB3: LOGO; Logo Aisler Micro
Q1: Q_NMOS_GSD; SOT-23
R1, R2: 60; R_0603_1608Metric
R3, R4: 4.7k; R_0603_1608Metric; not fitted
R5, R8, R11, R13: 510; R_0603_1608Metric
R6, R7: 4.7k; R_0603_1608Metric
R9, R10, R14, R15, R16, R17: 10k; R_0603_1608Metric
R12: 10k; R_0603_1608Metric; not fitted
R18, R19: 10K; R_0603_1608Metric
R20, R21, R22, R23, R24, R25, R26, R27, R28, R29, R30, R31, R32, R33: 220; R_0603_1608Metric
SW1: 435431019840
SW2: SW_DIP_x03; SW_DIP_SPSTx03_Slide_KingTek_DSHP03TS_W7.62mm_P1.27mm
U1: NCP718xSN330; SOT-23-5
U2: MCP2551-I-SN; SOIC-8_3.9x4.9mm_P1.27mm
U3: STM32G491KEUx; QFN-32-1EP_5x5mm_P0.5mm_EP3.45x3.45mm-Without thermal pad
U4: PCA9685PW; TSSOP-28_4.4x9.7mm_P0.65mm

Connections:
+3.3V: C6.1, C7.1, C8.1, C9.1, C11.1, D2.2 (A), J4.3, J21.1, J22.1, R3.1, R4.1, R6.1, R7.1, R12.1, U1.5 (OUT), U3.1 (VDD), U3.15 (VDDA), U3.17 (VDD)
+5P: C1.1, D1.2 (A), J7.3, J13.2, J17.2, J26.2, J28.2, J29.2, J30.2
+5VL: C2.1, C3.1, C13.2, J3.1, J24.1, J25.1, SW2.1, SW2.2, SW2.3, U1.1 (IN), U1.3 (EN), U2.3 (VDD), U4.28 (VDD)
+12P: C4.1, C12.1, C14.1, C17.1, C18.1, J1.2, J2.2, J5.2, J6.2, J7.2, J8.2, J9.2, J10.2, J11.2, J12.2, J16.1, J19.1, J23.1, J27.1
/AX12: J1.1, J2.1, J5.1, J6.1, J8.1, J9.1, J10.1, J11.1, J12.1
/BUS_SCL: JP3.3 (B), JP4.1 (A), R4.2, U3.25 (PA15)
/BUS_SDA: JP1.3 (B), JP5.1 (A), R3.2, U3.30 (PB7)
/CANH: JP1.1 (A), R1.2, U2.7 (CANH)
/CANL: JP3.1 (A), R2.1, U2.6 (CANL)
/CAN_RX: U2.4 (RXD), U3.28 (PB5)
/CAN_TX: U2.1 (TXD), U3.29 (PB6)
/EV1: J16.3, R31.2
/EV2: J19.3, R29.2
/EV3: J23.3, R22.2
/EV4: J27.3, R20.2
/MOTOR_DIR_1: J14.6, U3.21 (PA11)
/MOTOR_DIR_2: J15.6, U3.10 (PA5)
/MOTOR_EN: D4.2 (A), J14.4, J15.4, U3.5 (PA0)
/MOTOR_STP_1: J14.5, U3.20 (PA10)
/MOTOR_STP_2: J15.5, U3.9 (PA4)
/PUMP1: J16.2, R30.2
/PUMP2: J19.2, R28.2
/PUMP3: J23.2, R23.2
/PUMP4: J27.2, R21.2
/PWM0: J26.1, R32.2
/PWM1: J28.1, R33.2
/PWM2: J29.1, R26.2
/PWM3: J30.1, R27.2
/PWM4: J13.1, R25.2
/PWM5: J17.1, R24.2
/RST: J3.4, Q1.1 (G), R10.1
/SBE_SCL: J24.6, J25.6, JP4.2 (C), R7.2, U4.26 (SCL)
/SBE_SDA: J24.5, J25.5, JP5.2 (C), R6.2, U4.27 (SDA)
/SENSOR1: C15.1, J21.2, R18.1, U3.6 (PA1)
/SENSOR2: C16.1, J22.2, R19.1, U3.12 (PA7)
/STATUS: D3.2 (A), U3.13 (PB0)
/STM32_SCL: JP4.3 (B), U3.19 (PA9)
/STM32_SDA: JP5.3 (B), U3.18 (PA8)
/SWCLK: J4.6, U3.24 (PA14)
/SWDIO: J4.4, U3.23 (PA13)
/VCP_RX: J4.13, U3.8 (PA3)
/VCP_TX: J4.14, U3.7 (PA2)
/~RST: C10.1, J4.12, Q1.3 (D), R12.2, SW1.4, U3.4 (PG10)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.1, C14.2, C15.2, C16.2, C17.2, C18.2, H1.1, H2.1, H3.1, H4.1, J1.3, J2.3, J3.3, J4.5, J4.7, J4.11, J5.3, J6.3, J7.4, J7.5, J7.6, J8.3, J9.3, J10.3, J11.3, J12.3, J13.3, J14.2, J15.2, J16.4, J17.3, J18.2, J19.4, J20.2, J21.3, J22.3, J23.4, J24.3, J25.3, J26.3, J27.4, J28.3, J29.3, J30.3, Q1.2 (S), R5.2, R8.2, R9.2, R10.2, R11.2, R13.2, R14.2, R15.2, R16.1, R17.2, R18.2, R19.2, SW1.3, SW1.SH, U1.2 (GND), U2.2 (VSS), U2.8 (STBY), U3.14 (VSSA), U3.16 (VSS), U3.32 (VSS), U4.4 (A3), U4.5 (A4), U4.14 (VSS)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
unnamed: D1.1 (K), R5.1
unnamed: D2.1 (K), R8.1
unnamed: D3.1 (K), R11.1
unnamed: D4.1 (K), R13.1
unnamed: J3.5, JP1.2 (C)
unnamed: J3.6, JP3.2 (C)
unnamed: JP2.1 (A), R2.2
unnamed: JP2.3 (B), R1.1
unnamed: JP2.2 (C), U2.5 (SPLIT)
unnamed: R9.1, U3.31 (PB8)
unnamed: R14.1, SW2.6, U4.1 (A0)
unnamed: R15.1, SW2.5, U4.2 (A1)
unnamed: R17.1, SW2.4, U4.3 (A2)
unnamed: R20.1, U4.6 (LED0)
unnamed: R21.1, U4.7 (LED1)
unnamed: R22.1, U4.8 (LED2)
unnamed: R23.1, U4.9 (LED3)
unnamed: R24.1, U4.10 (LED4)
unnamed: R25.1, U4.11 (LED5)
unnamed: R26.1, U4.12 (LED6)
unnamed: R27.1, U4.13 (LED7)
unnamed: R28.1, U4.15 (LED8)
unnamed: R29.1, U4.16 (LED9)
unnamed: R30.1, U4.17 (LED10)
unnamed: R31.1, U4.18 (LED11)
unnamed: R32.1, U4.19 (LED12)
unnamed: R33.1, U4.20 (LED13)
unnamed: R16.2, U4.23 (~OE)
VPP: C5.1, J7.1, J14.1, J15.1, J18.1, J20.1

Notes on the sheet:
PCA can be on the addresses 0x40-0x47 (configured via SW1)
to enable termination, solder all 3 pads
config of SSBE with JP3/4 contacts 1-2 soldered = CAN contact 2-3 soldered = I2C
Config of SSBE I2C Contacts 1-2 : Main Interface Contacts 2-3 : STM32
CAN Transciever
I2C Bus Selection
AX12
Reset Circuit
3.3V Regulation
Logos
Stepper Motors
Servos
Main interface
Sensors
Mounting Holes
Leds
PSU
3.3V LDO
PWM Generator
STLINK

Board: 2 copper layers, 74.0 x 50.0 mm, 131 parts (35 on the bottom side), 73 nets.

Other parts of the board:
kibuzzard-69F98A1C: G***; kibuzzard-69F98A1C
kibuzzard-69F98A02: G***; kibuzzard-69F98A02
kibuzzard-69F98A4C, kibuzzard-69F98A4C#2: G***; kibuzzard-69F98A4C
kibuzzard-69F98A9B: G***; kibuzzard-69F98A9B
kibuzzard-69F98A15: G***; kibuzzard-69F98A15
kibuzzard-69F98A35: G***; kibuzzard-69F98A35
kibuzzard-69F98A63: G***; kibuzzard-69F98A63
kibuzzard-69F98ABA: G***; kibuzzard-69F98ABA
kibuzzard-69F98AD2: G***; kibuzzard-69F98AD2
kibuzzard-69F98AD9: G***; kibuzzard-69F98AD9
kibuzzard-69F98AE6: G***; kibuzzard-69F98AE6
kibuzzard-69F98AF4: G***; kibuzzard-69F98AF4
kibuzzard-69F98AFD: G***; kibuzzard-69F98AFD
kibuzzard-69F98B1A: G***; kibuzzard-69F98B1A
kibuzzard-69F98C19, kibuzzard-69F98C19#2: G***; kibuzzard-69F98C19
kibuzzard-69F98C37, kibuzzard-69F98C37#2: G***; kibuzzard-69F98C37
kibuzzard-69F98CF1: G***; kibuzzard-69F98CF1
kibuzzard-69F989A2: G***; kibuzzard-69F989A2
kibuzzard-69F989BF: G***; kibuzzard-69F989BF
kibuzzard-69F989DD: G***; kibuzzard-69F989DD
kibuzzard-69F989F3: G***; kibuzzard-69F989F3
kibuzzard-69F98969: G***; kibuzzard-69F98969
kibuzzard-69F98986, kibuzzard-69F98986#2: G***; kibuzzard-69F98986

## KiCad design Cartes PAL 2026/Carte Mobile/carte-mobile.kicad_pcb

Parts:
C1, C3: 10uF; C_0603_1608Metric
C2, C4: 100nF; C_0603_1608Metric
C5, C6, C7, C8: 4.7uF; C_0603_1608Metric
D1: RED; LED_0805_2012Metric
H1, H2, H3, H4: M3; MountingHole_3.2mm_M3_Pad_Via
J1: AX12 IN; 22-05-7035
J2: SBE I2C; 690367280676
J3: 12P PSU; 66200221022; not fitted
J4, J5, J6, J7: AX12; 22-05-7035
J8, J9, J10, J11: Color Sensor; 690367280676
J12, J13, J14, J15: Pump; S04B-PASK
JP1, JP2, JP3, JP4: SolderJumper_2_Open; SolderJumper-2_P1.3mm_Open_RoundedPad1.0x1.5mm
LB1: LOGO; logo-evo-min
LB2: LOGO; Logo Aisler Min
R1, R2: 4.7k; R_0603_1608Metric
R3, R4, R5, R6, R7, R8, R9, R10, R11: 10k; R_0603_1608Metric
SW1, SW2: SW_DIP_x03; SW_DIP_SPSTx03_Slide_KingTek_DSHP03TS_W7.62mm_P1.27mm
U1: NCP718xSN330; SOT-23-5
U2: TCA9548APWR; TSSOP-24_4.4x7.8mm_P0.65mm
U3: MCP23017_SS; SSOP-28_5.3x10.2mm_P0.65mm

Connections:
+3.3V: C2.1, C3.1, C4.1, D1.2 (A), J8.1, J9.1, J10.1, J11.1, R1.1, R2.1, R5.1, R10.1, SW1.1, SW1.2, SW1.3, SW2.1, SW2.2, SW2.3, U1.5 (OUT), U2.24 (VCC), U3.9 (VDD)
+5VL: C1.1, J2.1, U1.1 (IN), U1.3 (EN)
+12P: C5.1, C6.1, C7.1, C8.1, J1.2, J3.1, J4.2, J5.2, J6.2, J7.2, J12.1, J13.1, J14.1, J15.1
/AX12: J1.1, J4.1, J5.1, J6.1, J7.1
/EV1: J12.3, U3.2 (GPB1)
/EV2: J13.3, U3.4 (GPB3)
/EV3: J14.3, U3.6 (GPB5)
/EV4: J15.3, U3.8 (GPB7)
/INT0: J8.5
/INT1: J9.5
/INT2: J10.5
/INT3: J11.5
/LED0: J8.6, JP1.2 (B)
/LED1: J9.6, JP2.2 (B)
/LED2: J10.6, JP3.2 (B)
/LED3: J11.6, JP4.2 (B)
/PUMP1: J12.2, U3.1 (GPB0)
/PUMP2: J13.2, U3.3 (GPB2)
/PUMP3: J14.2, U3.5 (GPB4)
/PUMP4: J15.2, U3.7 (GPB6)
/SCL: J2.6, R2.2, U2.22 (SCL), U3.12 (SCK)
/SCL0: J8.3, U2.5 (SC0)
/SCL1: J9.3, U2.7 (SC1)
/SCL2: J10.3, U2.9 (SC2)
/SCL3: J11.3, U2.11 (SC3)
/SDA: J2.5, R1.2, U2.23 (SDA), U3.13 (SDA)
/SDA0: J8.4, U2.4 (SD0)
/SDA1: J9.4, U2.6 (SD1)
/SDA2: J10.4, U2.8 (SD2)
/SDA3: J11.4, U2.10 (SD3)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, H1.1, H2.1, H3.1, H4.1, J1.3, J2.3, J3.2, J4.3, J5.3, J6.3, J7.3, J8.2, J9.2, J10.2, J11.2, J12.4, J13.4, J14.4, J15.4, R3.2, R4.2, R6.2, R7.1, R8.2, R9.2, R11.2, U1.2 (GND), U2.12 (GND), U3.10 (VSS)
unnamed: D1.1 (K), R7.2
unnamed: JP1.1 (A), U3.21 (GPA0)
unnamed: JP2.1 (A), U3.22 (GPA1)
unnamed: JP3.1 (A), U3.23 (GPA2)
unnamed: JP4.1 (A), U3.24 (GPA3)
unnamed: R3.1, SW1.4, U2.1 (A0)
unnamed: R4.1, SW1.5, U2.2 (A1)
unnamed: R6.1, SW1.6, U2.21 (A2)
unnamed: R5.2, U2.3 (~RESET)
unnamed: R8.1, SW2.4, U3.15 (A0)
unnamed: R9.1, SW2.5, U3.16 (A1)
unnamed: R11.1, SW2.6, U3.17 (A2)
unnamed: R10.2, U3.18 (~RESET)

Notes on the sheet:
MCP can be mapped from 0x20 to 0x27 via SW2
TCA can be mapped from 0x70 to 0x77 via SW2
GPIO Expander
Mounting Holes
Color Sensors
Marking
I2C Multiplexer
AX12
Sous Bus Evo I2C
Sous Bus I2C
12P PSU

Board: 2 copper layers, 152.5 x 30.0 mm, 67 parts (4 on the bottom side), 40 nets.

Other parts of the board:
kibuzzard-69CA1A14: G***; kibuzzard-69CA1A14
kibuzzard-69CA1B5C: G***; kibuzzard-69CA1B5C
kibuzzard-69CA18C1: G***; kibuzzard-69CA18C1
kibuzzard-69CA18D8: G***; kibuzzard-69CA18D8
kibuzzard-69CA18E8: G***; kibuzzard-69CA18E8
kibuzzard-69CA191C: G***; kibuzzard-69CA191C
kibuzzard-69CA194B: G***; kibuzzard-69CA194B
kibuzzard-69CA198F: G***; kibuzzard-69CA198F
kibuzzard-69CA1904: G***; kibuzzard-69CA1904
kibuzzard-69CA1929: G***; kibuzzard-69CA1929
kibuzzard-69CA1933: G***; kibuzzard-69CA1933
kibuzzard-69CA1962: G***; kibuzzard-69CA1962
kibuzzard-69CA1972: G***; kibuzzard-69CA1972
kibuzzard-69CA1993, kibuzzard-69CA1993#2, kibuzzard-69CA1993#3, kibuzzard-69CA1993#4: G***; kibuzzard-69CA1993

## KiCad design Constellations actionneurs/Hololutek 2026 - Repartiteur/Repartiteur.kicad_pcb

Parts:
C5, C9: 10uF; C_0603_1608Metric
C6, C7: 100nF; C_0603_1608Metric
H1, H2, H3, H4: MountingHole_Pad; MountingHole_3.2mm_M3_Pad_Via
J1, J2, J3, J4, J5, J6, J7, J8: Conn_02x03_Odd_Even; 690367280676
J9: Sous-bus I2C; 690367280676
J10, J11: Conn_01x02; 66200221122
J12, J13, J15: AX12; 22-03-5035
J14: AX12; 22-05-7035
JP1, JP2, JP3, JP4, JP5, JP6: Jumper_3_Bridged12; SolderJumper-3_P1.3mm_Open_RoundedPad1.0x1.5mm
LB1: LOGO; logo-evo-micro
LB2: LOGO; Logo Aisler Micro
R1, R2, R3, R4, R5, R8, R9, R10, R11, R12: 4.7k; R_0603_1608Metric
R7, R31: 10k; R_0603_1608Metric
R13, R14, R15, R16, R17, R18, R19, R20, R21, R22, R23, R24, R25, R26, R27, R28: 220; R_0603_1608Metric
U1: NCP718xSN330; SOT-23-5
U2: PCA9685PW; TSSOP-28_4.4x9.7mm_P0.65mm
U3: TCA9548APWR; TSSOP-24_4.4x7.8mm_P0.65mm

Connections:
+3.3V: C6.1, C7.1, J1.1, J3.1, J5.1, J7.1, JP4.1 (A), JP5.1 (A), JP6.1 (A), R1.2, R2.2, R3.2, R4.1, R5.1, R8.2, R9.2, R10.2, R11.2, R12.2, R31.1, U1.5 (OUT), U3.24 (VCC)
+5VL: C5.1, C9.2, J9.1, JP1.1 (A), JP2.1 (A), JP3.1 (A), U1.1 (IN), U1.3 (EN), U2.28 (VDD)
+5VP: J1.6, J2.1, J2.2, J3.6, J4.1, J4.2, J5.6, J6.1, J6.2, J7.6, J8.1, J8.2, J10.1
+12P: J11.1, J12.2, J13.2, J14.2, J15.2
/LED_A: J5.5, R20.2
/LED_B: J1.5, R13.2
/LED_C: J3.5, R25.2
/LED_D: J7.5, R24.2
/SCL: J9.6, R5.2, U2.26 (SCL), U3.22 (SCL)
/SCL_A: J5.3, R1.1, U3.5 (SC0)
/SCL_B: J1.3, R3.1, U3.7 (SC1)
/SCL_C: J3.3, R9.1, U3.9 (SC2)
/SCL_D: J7.3, R11.1, U3.11 (SC3)
/SDA: J9.5, R4.2, U2.27 (SDA), U3.23 (SDA)
/SDA_A: J5.4, R2.1, U3.4 (SD0)
/SDA_B: J1.4, R8.1, U3.6 (SD1)
/SDA_C: J3.4, R10.1, U3.8 (SD2)
/SDA_D: J7.4, R12.1, U3.10 (SD3)
/SERVO_1A: J6.4, R19.2
/SERVO_1B: J2.4, R15.2
/SERVO_1C: J4.4, R28.2
/SERVO_1D: J8.4, R21.2
/SERVO_2A: J6.5, R17.2
/SERVO_2B: J2.5, R14.2
/SERVO_2C: J4.5, R27.2
/SERVO_2D: J8.5, R22.2
/SERVO_3A: J6.6, R18.2
/SERVO_3B: J2.6, R16.2
/SERVO_3C: J4.6, R26.2
/SERVO_3D: J8.6, R23.2
GND: C5.2, C6.2, C7.2, C9.1, H1.1, H2.1, H3.1, H4.1, J1.2, J2.3, J3.2, J4.3, J5.2, J6.3, J7.2, J8.3, J9.3, J10.2, J11.2, J12.3, J13.3, J14.3, J15.3, JP1.3 (B), JP2.3 (B), JP3.3 (B), JP4.3 (B), JP5.3 (B), JP6.3 (B), R7.1, U1.2 (GND), U2.4 (A3), U2.5 (A4), U2.14 (VSS), U2.24 (A5), U2.25 (EXTCLK), U3.12 (GND)
unnamed: J12.1, J13.1, J14.1, J15.1
unnamed: JP1.2 (C), U2.1 (A0)
unnamed: JP2.2 (C), U2.2 (A1)
unnamed: JP3.2 (C), U2.3 (A2)
unnamed: JP4.2 (C), U3.21 (A2)
unnamed: JP5.2 (C), U3.2 (A1)
unnamed: JP6.2 (C), U3.1 (A0)
unnamed: R13.1, U2.6 (LED0)
unnamed: R14.1, U2.7 (LED1)
unnamed: R15.1, U2.8 (LED2)
unnamed: R16.1, U2.9 (LED3)
unnamed: R17.1, U2.10 (LED4)
unnamed: R18.1, U2.11 (LED5)
unnamed: R19.1, U2.12 (LED6)
unnamed: R20.1, U2.13 (LED7)
unnamed: R28.1, U2.15 (LED8)
unnamed: R27.1, U2.16 (LED9)
unnamed: R26.1, U2.17 (LED10)
unnamed: R25.1, U2.18 (LED11)
unnamed: R24.1, U2.19 (LED12)
unnamed: R23.1, U2.20 (LED13)
unnamed: R22.1, U2.21 (LED14)
unnamed: R21.1, U2.22 (LED15)
unnamed: R7.2, U2.23 (~OE)
unnamed: R31.2, U3.3 (~RESET)

Notes on the sheet:
(12VL)
(RST)
Power input : 5V for servos, 12V for AX12s (optional)
PWM Driver for servo control
AX12 Hub
I2C Multiplexer for color sensors
Logo
I2C Input from the robot
Mounting
3.3V Regulation
Other
TODO (Pas possible actuellement sans ajouter un IC)
Outputs
Processing
Inputs

Board: 2 copper layers, 100.0 x 33.1 mm, 62 parts (6 on the bottom side), 56 nets.

## KiCad design Constellations actionneurs/Hololutek 2026 - Doigts/Doigts.kicad_pcb

Parts:
C1: 100nF; C_0603_1608Metric
C2: 1uF; C_0603_1608Metric
D1: LED; LED_0805_2012Metric
H1, H2, H3, H4: MountingHole_Pad; MountingHole_3.2mm_M3
J1, J2, J3: Conn_01x03; 22-03-5035
J4: Conn_01x07; PinSocket_1x07_P2.54mm_Vertical
J5, J6: Conn_02x03_Odd_Even; 690367280676
LB1: LOGO; Logo Aisler Micro
LB2: LOGO; logo-evo-micro
R1: 2k; R_0603_1608Metric

Connections:
+3.3V: C1.1, J4.3, J5.1
+5VP: C2.1, J1.2, J2.2, J3.2, J6.1, J6.2
/LED: J4.7, J5.5
/SCL: J4.4, J5.3
/SDA: J4.5, J5.4
/SERVO_1: J1.1, J6.4
/SERVO_2: J2.1, J6.5
/SERVO_3: J3.1, J6.6
/STATUS: J5.6, R1.1
GND: C1.2, C2.2, D1.1 (K), J1.3, J2.3, J3.3, J4.2, J5.2, J6.3
unnamed: D1.2 (A), R1.2

Notes on the sheet:
(INT)

Board: 2 copper layers, 44.0 x 19.5 mm, 16 parts (3 on the bottom side), 11 nets.
